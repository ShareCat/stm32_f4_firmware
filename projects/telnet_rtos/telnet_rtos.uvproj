# Keil uVision project telnet_rtos.uvproj, settings and files
target telnet_rtos (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: telnet_rtos +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER __CORTEX_M4F __FPU_PRESENT __CMSIS_RTOS
  c misc: --diag_suppress=3731
  c include: .;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4x7_ETH_Driver\inc;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\libraries\STM32F4-Discovery;..\..\libraries\LWIP-1.4.1\port\STM32F4x7;..\..\libraries\LWIP-1.4.1\src\include;..\..\libraries\LWIP-1.4.1\src\include\ipv4;..\..\libraries\LWIP-1.4.1\src\include\lwip;..\..\libraries\LWIP-1.4.1\src\include\netif;..\..\libraries\LWIP-1.4.1\port\STM32F4x7\arch;..\..\libraries\RTX-v4.79\INC;..\..\libraries\RTX-v4.79\SRC
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c netconf.c telnet.c shell.c stm32f4xx_it.c system_stm32f4xx.c stm32f4x7_eth_bsp.c
    ./: event.c leds.c blink.c uart.c
  group LWIP
    ../../libraries/LWIP-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../libraries/LWIP-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../libraries/LWIP-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c pbuf.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../libraries/LWIP-1.4.1/src/netif/: etharp.c slipif.c
    ../../libraries/LWIP-1.4.1/port/STM32F4x7/arch/: ethernetif.c sys_arch.c
  group RTX Configuration
    ./: RTX_Conf_CM.c
  group RTX Kernel
    ../../libraries/RTX-v4.79/SRC/: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
  group RTX HAL
    ../../libraries/RTX-v4.79/SRC/ARM/: SVC_Table.s HAL_CM4.c
    ../../libraries/RTX-v4.79/SRC/: HAL_CM.c
  group STM32F4-Discovery
    ../../libraries/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_sdio.c
  group STM32F4x7_ETH_Driver
    ../../libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group MDK-ARM
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
