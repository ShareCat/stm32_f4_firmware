# Keil uVision project blinky.uvprojx, settings and files
target blinky (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER __CORTEX_M4F __FPU_PRESENT __CMSIS_RTOS
  c misc: --diag_suppress=3731
  c include: .;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\RTX-v4.79\INC;..\..\libraries\RTX-v4.79\SRC;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc
  asm misc: --cpreproc --cpreproc_opts='-D__BLINKY'
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application
    ./: main.c leds.c uart.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group MDK-ARM
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Readme
    ./: readme.txt
